# IAR project WaterTreatmentSystem.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: wts_lnk430Fxxx.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F135 MSP430F135
  ICC430.CCDefines: NDEBUG
  group (top)
    ./: anin.c clk.c comms.c cooling_air_valve.c crc.c fail_safe.c fls.c flt.c globals.c gsebus_ser.c main.c pio.c reflash.c rtc.c solenoids.c steam_flow.c timers.c utility.c wdg.c
